# KOMPAS-3D part (Правый рельс X.m3d)

Model tree:
1. Операция без истории:1
