# KOMPAS-3D part (Левый рельс X.m3d)

Model tree:
1. Операция без истории:1
