# KOMPAS-3D part (Левая продольная балка основания.m3d)

Model tree:
1. Эскиз:1
2. Операция выдавливания:1
     Расстояние 1 = 450
