# KOMPAS-3D part (Уголок 30х30.m3d)

Model tree:
1. Операция без истории:1  (with: Операция без истории:2, Операция без истории:3, Операция без истории:4, Операция без истории:5)
